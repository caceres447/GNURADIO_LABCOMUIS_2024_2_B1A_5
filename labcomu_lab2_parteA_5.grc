options:
  parameters:
    generate_options: qt_gui
    id: labcomu_lab2_parteA_1
    output_language: python
    title: lab2parteA5
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: amplitud señal
    start: '0'
    step: '10e-3'
    stop: '500e-3'
    value: '500e-3'
  states: {}
- name: 'No'
  id: variable_qtgui_range
  parameters:
    label: amplitud radio
    start: '0'
    step: '1e-6'
    stop: '2'
    value: '100e-6'
  states: {}
- name: fcut
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '100'
    stop: samp_rate/2
    value: 1.5625e6
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: frecuencia señal
    start: 1e3
    step: 1e3
    stop: 1e6
    value: 10e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 3.125e6
  states: {}
- name: t_band
  id: variable_qtgui_range
  parameters:
    label: 'banda de transicion '
    start: '0'
    step: '100'
    stop: samp_rate/20
    value: 156.25e3
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: 'No'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/labcomu/Descargas/rebelion_joearroyo.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: fcut
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: t_band
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(44.1e3)
    interp: int(samp_rate)
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate)
    interp: int(44.1e3)
    type: fff
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_1, '1']
- [blocks_add_xx_1, '0', low_pass_filter_0, '0']
- [blocks_throttle2_0, '0', blocks_add_xx_1, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_throttle2_0, '0']
- [rational_resampler_xxx_0_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-810-g1ecb8565
